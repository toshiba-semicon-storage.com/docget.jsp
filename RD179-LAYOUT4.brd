# Allegro board RD179-LAYOUT4.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
N16845354 on TOP: 4.58,41.5 4.52,41.52 4.5,41.58 4.5,44.42 4.52,44.48 4.58,44.5 11.68,44.5 11.73,44.48 11.75,44.42 11.75,41.58 11.73,41.52 11.68,41.5
N16845404 on TOP: 34.25,32 34.23,32.02 32,34.25 27.82,34.25 27.77,34.27 27.75,34.33 27.75,38.17 27.77,38.23 27.82,38.25 32.72,38.25 32.75,38.24 32.77,38.23 36.5,34.5 40.72,34.5 40.75,34.49 40.77,34.48 41.25,34 43.17,34 43.23,33.98 43.25,33.92 43.25,32.08 43.23,32.02 43.17,32 34.39,32
N16845627 on TOP: 38.58,21.75 38.52,21.77 38.5,21.82 38.5,23.43 38.52,23.48 38.58,23.5 42.17,23.5 42.23,23.48 42.25,23.43 42.25,21.82 42.23,21.77 42.17,21.75
N16845798 on TOP: 38.08,27.5 38.02,27.52 38,27.57 38,30.43 38.02,30.48 38.08,30.5 43.17,30.5 43.23,30.48 43.25,30.43 43.25,28.79 43.21,28.72 43.13,28.73 42.11,28.86 41.56,28 41.56,27.97 41.43,27.57 41.4,27.52 41.38,27.51 41.35,27.5
N16846127 on TOP: 4.58,71 4.52,71.02 4.5,71.08 4.5,73.92 4.52,73.98 4.58,74 11.68,74 11.73,73.98 11.75,73.92 11.75,71.08 11.73,71.02 11.68,71
N16846795 on TOP: 41.03,9.75 41,9.76 40.98,9.77 40.52,10.23 40.51,10.25 40.5,10.28 40.5,12.68 40.52,12.73 40.58,12.75 43.17,12.75 43.23,12.73 43.25,12.68 43.25,9.82 43.23,9.77 43.17,9.75
N16846795 on TOP: 38.08,13.5 38.02,13.52 38,13.57 38,15.43 38.02,15.48 38.08,15.5 39.92,15.5 39.98,15.48 40,15.43 40,13.57 39.98,13.52 39.92,13.5
N16847047 on TOP: 4.58,19.5 4.52,19.52 4.5,19.57 4.5,22.43 4.52,22.48 4.58,22.5 11.93,22.5 11.98,22.48 12,22.43 12,19.57 11.98,19.52 11.93,19.5
N16847824 on TOP: 27.82,39.5 27.77,39.52 27.75,39.58 27.75,43.92 27.77,43.98 27.82,44 32.92,44 32.98,43.98 33,43.92 33,39.58 32.98,39.52 32.92,39.5
N16854424 on TOP: 4.58,30.5 4.52,30.52 4.5,30.57 4.5,33.42 4.52,33.48 4.58,33.5 9.68,33.5 9.73,33.48 9.75,33.42 9.75,30.57 9.73,30.52 9.68,30.5

Small or netless copper shapes (teardrops, artwork): 113 on TOP, 115 on BOTTOM

## Text on the board
PAGE_OUTLINE: K | 1 | R10 | R12 | R11 | SJP3 | + | SJP4 | R2 | R4 | R1 | U1 | R3 | C8 | LEDP1 | R43 | D1 | J3 | TP11 | R46 | C34 | C19 | TP13 | C36 | R39 | C33 | TP9 | R33 | L1 | R29 | C30 | U2 | R35 | C6 | U6 | R16 | U8 | C7 | C18 | TP8 | TP7 | U5 | R54 | C26 | C31 | C11 | TP10 | TP12 | J10 | C16 | C21 | C20 | C24 | R18 | TP6 | U7 | S_SW1 | TST1 | R50 | TST2 | R51 | S_SW2 | TST3 | C38 | C25 | R52 | S_SW3 | S_SW4 | R53 | J4 | JP1 | 2 | 3 | J2 | J1 | L4 | L3 | L2 | F1 | SJP2 | SJP1 | C9 | C12 | C10 | R5 | C37 | R48 | C35 | C2 | C1 | TP5 | R13 | C15 | R17 | C32 | C14 | C3 | TP14 | SW1 | R45 | R37 | R44 | R47 | TP4 | R49 | D6 | R42 | TP15 | R41 | D2 | R38 | C27 | D5 | TP3 | R14 | R28 | R32 | R34 | TP16 | R27 | D4 | C4 | C13 | R7 | TP1 | R6 | J7 | C5 | Y1 | R19 | C22 | 7 | J6 | 8 | J9 | C29 | LED1 | R25 | VR1 | LED2 | R30 | LED3 | R36 | LEDP2 | R15 | C39 | C40 | R22 | 19 | 5 | J8 | J5 | 20 | DC INPUT | 120-340V | GND | FUSE 440V-10A | EXT.CONTROL | - | U | W | V | AD_W | UH | EMG | AVDD | UL | RESET | VH | VL | WH | DVDD | AD_V | WL | AD_U | AVSS | DVSS | RELAY | EXT.DAC | BOOT | DC15V | DEBUG | DC5V | SWD
